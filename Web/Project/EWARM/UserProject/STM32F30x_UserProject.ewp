# IAR project STM32F30x_UserProject.ewp, settings and files
configuration STM32303C-EVAL_SINGLEDRIVE (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VB ST STM32F303VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; USE_STM32303C_EVAL; ARM_MATH_CM4; CCMRAM; STM32F303X
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F30x\Include; ..\..\..\..\Common\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32F30x_CPAL_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STM32303C_EVAL; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCLibrary\interface\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\; ..\..\..\PFC_Application\interface\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STEVAL_ESC001V1.hex
  ILINK.IlinkOutputFile: STM32F30x_UserProject.out
  ILINK.IlinkIcfFile: stm32f303_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32303C-EVAL_DUALDRIVE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  OBJCOPY.OOCOutputFile: STM32F30x_UserProject.srec
  ILINK.IlinkOutputFile: STM32303C-EVAL.out
  ILINK.IlinkAdditionalLibs: ..\..\..\PFC_Project\EWARM\PFC Application Compiled\Exe\STM32F30x_PFC_Project.a
configuration STM32F302_SINGLEDRIVE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F302xC ST STM32F302xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; USE_STM32303C_EVAL; ARM_MATH_CM4; STM32F302X
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F30x\Include; ..\..\..\..\Common\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32F30x_CPAL_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STM32303C_EVAL; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCLibrary\interface\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\
  OBJCOPY.OOCOutputFile: STM32F30x_UserProject.srec
  ILINK.IlinkOutputFile: STM32303C-EVAL.out
  ILINK.IlinkIcfFile: stm32f302_flash.icf
configuration P-NUCLEO-IHM001_SINGLEDRIVE (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F302R8 ST STM32F302R8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; STM32F302x8; P_NUCLEO_IHM001; ARM_MATH_CM4
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: STM32F30x_UserProject.srec
  ILINK.IlinkOutputFile: STM32303C-EVAL.out
  ILINK.IlinkIcfFile: stm32f302_flash.icf
  group (top)
    ../../: GAPApplication.c GAPApplication.h I2C_Params.h main.c stm32f30x_it.c Timebase.c
    ../../../: readme.txt
    ../../../SystemDriveParams/: stm32f30x_MC_it.c
  group Motor Control/MC Application/interface
    ../../../MCApplication/interface/: MC.h MCInterfaceClass.h MCTasks.h MCTuningClass.h
  group Motor Control/MC Application/private
    ../../../MCApplication/inc/: MCInterfaceClassPrivate.h MCInterfacePrivate.h MCTuningClassPrivate.h MCTuningPrivate.h
  group Motor Control/MC Application/src
    ../../../MCApplication/src/: MCInterfaceClass.c MCTasks.c MCTuningClass.c
  group Motor Control/MC Library/interface
    ../../../MCLibrary/interface/: BusVoltageSensorClass.h CircleLimitationClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HALL_F30X_SpeednPosFdbkClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h ICS_DD_PWMnCurrFdbkClass.h ICS_F30X_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h MTPACtrlClass.h NTC_TemperatureSensorClass.h OpenLoopClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_F30X_PWMnCurrFdbkClass.h R3_1_F30X_PWMnCurrFdbkClass.h R3_2_F30X_PWMnCurrFdbkClass.h R3_4_F30X_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h
  group Motor Control/MC Library/interface/common
    ../../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h
  group Motor Control/MC Library/lib
    ../MC Library Compiled/Exe/: MC_Library_STM32F302_single_drive.a MC_Library_STM32F302x8_single_drive.a MC_Library_STM32F303_dual_drive.a
    ../mc library compiled/Exe/: MC_Library_STM32F303_single_drive.a
  group Motor Control/System & Drive Params
    ../../../SystemDriveParams/: Parameters conversion_F30x motor 2.h Parameters conversion_F30x.h SystemNDriveParams.h
  group Motor Control/System & Drive Params/Motor1
    ../../../SystemDriveParams/: Control stage parameters.h Drive parameters.h Parameters conversion.h PMSM motor parameters.h Power stage parameters.h
  group Motor Control/System & Drive Params/Motor2
    ../../../SystemDriveParams/: Control stage parameters motor 2.h Drive parameters motor 2.h Parameters conversion motor 2.h PMSM motor 2 parameters.h Power stage parameters motor 2.h
  group Std project template/CMSIS
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_init_f32.c
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
  group Std project template/EWARM
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f302.s startup_stm32f303.s
  group Std project template/StdPeriph_Drivers
    ../../../../Common/Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group Std project template/STM32_EVAL
    ../../../../Common/Libraries/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval.c stm32303c_eval_i2c_ee.c stm32303c_eval_i2c_tsensor.c stm32303c_eval_lcd.c stm32303c_eval_spi_ee.c stm32303c_eval_spi_sd.c
  group STEVAL-ESC001V1
    ../../: STEVAL_ESC001V1.c
  group User Interface/UI Library/interface
    ../../../UILibrary/interface/: DAC_F30X_UserInterfaceClass.h FrameCommunicationProtocolClass.h I2C_PhysicalLayerCommunication_Class.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h LCDVintage_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h UnidirectionalFastCom_UserInterfaceClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group User Interface/UI Library/private
    ../../../UILibrary/inc/: DAC_F30X_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h I2C_PhysicalLayerCommunication_Private.h LCD_Interface.h LCDManager_UserInterfacePrivate.h LCDVintage_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h UnidirectionalFastCom_UserInterfacePrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h
  group User Interface/UI Library/src
    ../../../UILibrary/src/: DAC_F30X_UserInterfaceClass.c DACSPIAD7303DUAL_F3XX_UserInterfaceClass.c FrameCommunicationProtocolClass.c I2C_PhysicalLayerCommunication_Class.c LCDManager_UserInterfaceClass.c LCDVintage_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c UnidirectionalFastCom_F3XX_UserInterfaceClass.c USART_F30X_PhysicalLayerCommunication_Class.c UserInterfaceClass.c
    ../../: UITask.c
