# IAR project STM32F30x_MC Library.ewp, settings and files
configuration STM32F303_SINGLE_DRIVE (ARM)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; MC_LIBRARY_SINGLE; ARM_MATH_CM4; CCMRAM
  ICCARM.CCIncludePath2: ..\; ..\..\MCLibrary\; ..\..\MCLibrary\inc\; ..\..\MCLibrary\protected_sources\inc\; ..\..\MCLibrary\interface\; ..\..\MCLibrary\interface\common\; ..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F30x\Include\; ..\..\..\Common\Libraries\STM32F30x_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MC architecture.srec
  ILINK.IlinkOutputFile: MC architecture.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F303_DUAL_DRIVE (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; MC_LIBRARY_DUAL; ARM_MATH_CM4; CCMRAM
configuration STM32F302_SINGLE_DRIVE (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F302xB ST STM32F302xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; MC_LIBRARY_SINGLE; ARM_MATH_CM4
configuration STM32F302x8_SINGLE_DRIVE (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F302x8 ST STM32F302x8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; STM32F302x8; MC_LIBRARY_SINGLE; ARM_MATH_CM4
  group (top)
    ../../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
  group MC Library
    ../../MCLibrary/: MCLibraryConf.h stm32f30x_MisraCompliance.h
  group MC Library/interface
    ../../MCLibrary/interface/: BusVoltageSensorClass.h CircleLimitationClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h GAP_GateDriverCtrlClass.h GateDriverCtrlClass.h HALL_F30X_SpeednPosFdbkClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h ICS_F30X_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h MTPACtrlClass.h NTC_TemperatureSensorClass.h OneTouchTuningClass.h OpenLoopClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_F30X_PWMnCurrFdbkClass.h R3_1_F30X_PWMnCurrFdbkClass.h R3_2_F30X_PWMnCurrFdbkClass.h R3_4_F30X_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SelfComCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h
  group MC Library/interface/common
    ../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h PID_PIRegulatorClass.h PIRegulatorClass.h RampExtMngrClass.h RampMngrClass.h
  group MC Library/obj/Dual Drive F303
    ../../MCLibrary/obj/CM4 CCM/Dual Drive/: FeedForwardCtrlClass.o FluxWeakeningCtrlClass.o HiFreqInj_FPU_CtrlClass.o MTPACtrlClass.o RevupCtrlClass.o STO_CORDIC_SpeednPosFdbkClass.o STO_SpeednPosFdbkClass.o
  group MC Library/obj/Single Drive F302
    ../../MCLibrary/obj/CM4/Single Drive/: FeedForwardCtrlClass.o FluxWeakeningCtrlClass.o HiFreqInj_FPU_CtrlClass.o MTPACtrlClass.o OneTouchTuningClass.o RevupCtrlClass.o SelfComCtrlClass.o STO_CORDIC_SpeednPosFdbkClass.o STO_SpeednPosFdbkClass.o
  group MC Library/obj/Single Drive F303
    ../../MCLibrary/obj/CM4 CCM/Single Drive/: FeedForwardCtrlClass.o FluxWeakeningCtrlClass.o HiFreqInj_FPU_CtrlClass.o MTPACtrlClass.o OneTouchTuningClass.o RevupCtrlClass.o SelfComCtrlClass.o STO_CORDIC_SpeednPosFdbkClass.o STO_SpeednPosFdbkClass.o
  group MC Library/private
    ../../MCLibrary/inc/: BusVoltageSensorPrivate.h CircleLimitationPrivate.h DigitalOutputClass_F30XPrivate.h ENC_F30X_SpeednPosFdbkPrivate.h EncAlignCtrlPrivate.h HALL_F30X_SpeednPosFdbkPrivate.h HiFreqInj_FPU_SpeednPosFdbkPrivate.h InrushCurrentLimiterPrivate.h MCIRQHandlerPrivate.h MotorPowerMeasurementPrivate.h OpenLoopPrivate.h PID_PIRegulatorPrivate.h PIRegulatorPrivate.h PQD_MotorPowerMeasurementPrivate.h PWMnCurrFdbkPrivate.h R1_F30X_PWMnCurrFdbkPrivate.h R3_1_F30X_PWMnCurrFdbkPrivate.h R3_2_F30X_PWMnCurrFdbkPrivate.h R3_4_F30X_PWMnCurrFdbkPrivate.h RampExtMngrPrivate.h RampMngrPrivate.h Rdivider_F30X_BusVoltageSensorPrivate.h SpeednPosFdbkPrivate.h SpeednTorqCtrlPrivate.h StateMachinePrivate.h TemperatureSensorPrivate.h Virtual_BusVoltageSensorPrivate.h Virtual_TemperatureSensorPrivate.h VirtualSpeedSensor_SpeednPosFdbkPrivate.h
  group MC Library/src
    ../../MCLibrary/src/: BusVoltageSensorClass.c CircleLimitationClass.c DigitalOutputClass_F30X.c ENC_F30X_SpeednPosFdbkClass.c EncAlignCtrlClass.c HALL_F30X_SpeednPosFdbkClass.c HiFreqInj_FPU_SpeednPosFdbkClass.c ICS_F30X_PWMnCurrFdbkClass.c InrushCurrentLimiterClass.c MC_Math.c MCIRQHandlerClass.c MotorPowerMeasurementClass.c NTC_F30X_TemperatureSensorClass.c OpenLoopClass.c PID_PIRegulatorClass.c PIRegulatorClass.c PQD_MotorPowerMeasurementClass.c PWMnCurrFdbkClass.c R1_F30X_PWMnCurrFdbkClass.c R3_1_F30X_PWMnCurrFdbkClass.c R3_2_F30X_PWMnCurrFdbkClass.c R3_4_F30X_PWMnCurrFdbkClass.c RampExtMngrClass.c RampMngrClass.c Rdivider_F30X_BusVoltageSensorClass.c SpeednPosFdbkClass.c SpeednTorqCtrlClass.c StateMachineClass.c TemperatureSensorClass.c Virtual_BusVoltageSensorClass.c Virtual_TemperatureSensorClass.c VirtualSpeedSensor_SpeednPosFdbkClass.c
